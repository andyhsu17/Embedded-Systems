# Keil uVision project boostxl_edumkII_lightSensor_msp432p401r.uvprojx, settings and files
target boostxl_edumkII_lightSensor_msp432p401r (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: boostxl_edumkII_lightSensor_msp432p401r
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __MSP432P401R__
  c include: ..\..\..\..\..\..\source;..\..\..\..\..\..\source\third_party\CMSIS\Include;..;..\LcdDriver
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source
    ../: HAL_I2C.c HAL_I2C.h HAL_OPT3001.c HAL_OPT3001.h main.c system_msp432p401r.c
    ./: startup_msp432p401r_uvision.s
  group Fonts
    ../../../../../../source/ti/grlib/fonts/: fontfixed6x8.c
  group LcdDriver
    ../LcdDriver/: Crystalfontz128x128_ST7735.c Crystalfontz128x128_ST7735.h HAL_MSP_EXP432P401R_Crystalfontz128x128_ST7735.c HAL_MSP_EXP432P401R_Crystalfontz128x128_ST7735.h
  group Library
    ../../../../../../source/ti/devices/msp432p4xx/driverlib/keil/: msp432p4xx_driverlib.lib
    ../../../../../../source/ti/grlib/keil/: grlib.lib
