<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/msp-exp432p401r_grlib_example.ewp</path>
  </project>
  <batchBuild/>
</workspace>
