# Keil uVision project msp_exp432p401r_grLib_example.uvprojx, settings and files
target msp_exp432p401r_grLib_example (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.1.0
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: msp_exp432p401r_grLib_example
  AfterMake: fromelf --bin --output .\Build\msp_exp432p401r_grLib_example.bin .\Build\msp_exp432p401r_grLib_example.axf
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __MSP432P401R__
  c include: ../../../../../../source ; ../../../../../../source/third_party/CMSIS/Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source
    ../: main.c system_msp432p401r.c touch_P401R.c
    ./: startup_msp432p401r_uvision.s
  group Library
    ../../../../../../source/ti/devices/msp432p4xx/driverlib/keil/: msp432p4xx_driverlib.lib
    ../../../../../../source/ti/grlib/keil/: grlib.lib
  group LcdDriver
    ../LcdDriver/: HAL_MSP_EXP432P4_KITRONIX320X240_SSD2119_SPI.c kitronix320x240x16_ssd2119_spi.c
  group images
    ../images/: Images_Button.c lcd_color_320x240.c Primitives_Button.c TI_logo_150x150.c TI_platform_bar_red.c
  group fonts
    ../../../../../../source/ti/grlib/fonts/: fontcm12.c fontcm12b.c fontcm12i.c fontcm14.c fontcm14b.c fontcm14i.c fontcm16.c fontcm16b.c fontcm16i.c fontcm18.c fontcm18b.c fontcm18i.c fontcm20.c fontcm20b.c fontcm20i.c fontcm22.c fontcm22b.c fontcm22i.c fontcm24.c fontcm24b.c fontcm24i.c fontcm26.c fontcm26b.c fontcm26i.c fontcm28.c fontcm28b.c fontcm28i.c fontcm30.c fontcm30b.c fontcm30i.c fontcm32.c fontcm32b.c fontcm32i.c fontcm34.c fontcm34b.c fontcm34i.c fontcm36.c fontcm36b.c fontcm36i.c fontcm38.c fontcm38b.c fontcm38i.c fontcm40.c fontcm40b.c fontcm40i.c fontcm42.c fontcm42b.c fontcm42i.c fontcm44.c fontcm44b.c fontcm44i.c fontcm46.c fontcm46b.c fontcm46i.c fontcm48.c fontcm48b.c fontcm48i.c fontcmsc12.c fontcmsc14.c fontcmsc16.c fontcmsc18.c fontcmsc20.c fontcmsc22.c fontcmsc24.c fontcmsc26.c fontcmsc28.c fontcmsc30.c fontcmsc32.c fontcmsc34.c fontcmsc36.c fontcmsc38.c fontcmsc40.c fontcmsc42.c fontcmsc44.c fontcmsc46.c fontcmsc48.c fontcmss12.c fontcmss12b.c fontcmss12i.c fontcmss14.c fontcmss14b.c fontcmss14i.c fontcmss16.c fontcmss16b.c fontcmss16i.c fontcmss18.c fontcmss18b.c fontcmss18i.c fontcmss20.c fontcmss20b.c fontcmss20i.c fontcmss22.c fontcmss22b.c fontcmss22i.c fontcmss24.c fontcmss24b.c fontcmss24i.c fontcmss26.c fontcmss26b.c fontcmss26i.c fontcmss28.c fontcmss28b.c fontcmss28i.c fontcmss30.c fontcmss30b.c fontcmss30i.c fontcmss32.c fontcmss32b.c fontcmss32i.c fontcmss34.c fontcmss34b.c fontcmss34i.c fontcmss36.c fontcmss36b.c fontcmss36i.c fontcmss38.c fontcmss38b.c fontcmss38i.c fontcmss40.c fontcmss40b.c fontcmss40i.c fontcmss42.c fontcmss42b.c fontcmss42i.c fontcmss44.c fontcmss44b.c fontcmss44i.c fontcmss46.c fontcmss46b.c fontcmss46i.c fontcmss48.c fontcmss48b.c fontcmss48i.c fontcmtt12.c fontcmtt14.c fontcmtt16.c fontcmtt18.c fontcmtt20.c fontcmtt22.c fontcmtt24.c fontcmtt26.c fontcmtt28.c fontcmtt30.c fontcmtt32.c fontcmtt34.c fontcmtt36.c fontcmtt38.c fontcmtt40.c fontcmtt42.c fontcmtt44.c fontcmtt46.c fontcmtt48.c fontfixed6x8.c
software components: CMSIS:CORE 4.3.0
